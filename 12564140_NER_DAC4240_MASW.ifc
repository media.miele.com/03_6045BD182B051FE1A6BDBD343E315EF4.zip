Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: f2c65854-c0c0-4517-9508-6c73b239cb49, NumberOfSaves: 1]
File name: 0001
Time: 2026-08-12T10:18:03+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12564140_NER_DAC4240_MASW:28C4240M_NER_12564140_DAC4240_MASW, (2)
In: Default
Type - Material: z_Miele_Design_CLST, <Unnamed>, z_Miele_Connection_Electric, z_Miele_Design_Cast
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 1165 mm; Height: 196 mm; Depth: 500 mm
Pset_BuildingElementProxyCommon - Reference: 28C4240M_NER_12564140_DAC4240_MASW; sets with these values: 2
